options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: decode_sdr
    output_language: python
    title: LELEC2102 - Decode SDR with FPGA
  states: {}

blocks:
- name: Enable_FPGA_FIR
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: Enable_detection
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: K_threshold
  id: variable
  parameters:
    value: '7'
  states: {state: disabled}
- name: K_threshold
  id: variable
  parameters:
    value: '10'
  states: {}
- name: N_Moose
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Print_metrics
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: Print_payload
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 870.009e6
  states: {}
- name: crc_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: detect_threshold_entry
  id: variable_qtgui_range
  parameters:
    label: detect_threshold_entry
    start: '0.1'
    step: '0.005'
    stop: '0.8'
    value: '0.6'
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/2
  states: {}
- name: hdr_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: melvec_length
  id: variable
  parameters:
    value: '20'
  states: {}
- name: n_melvecs
  id: variable
  parameters:
    value: '20'
  states: {}
- name: noiseQuery
  id: variable_qtgui_push_button
  parameters:
    label: Noise estimation query
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: oversampling
  id: variable
  parameters:
    value: '8'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: hdr_len+payload_len+crc_len
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: payload_len_hamming
  states: {}
- name: payload_len_hamming
  id: variable
  parameters:
    value: '985'
  states: {}
- name: payload_len_no_hamming
  id: variable
  parameters:
    value: '824'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*oversampling
  states: {}
- name: spectrogram_len
  id: variable
  parameters:
    value: n_melvecs*melvec_length*2
  states: {}
- name: tx_power
  id: variable_qtgui_entry
  parameters:
    label: TX power used (no impact, just for logging)
    type: int
    value: '0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: fsk_demodulation_0
  id: fsk_demodulation
  parameters:
    crc_len: crc_len
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    payload_len: payload_len
  states: {}
- name: fsk_onQuery_noise_estimation_0
  id: fsk_onQuery_noise_estimation
  parameters:
    n_est: '10'
    n_samples: '1024'
    osr: oversampling
    query: noiseQuery
  states: {}
- name: fsk_packet_parser_0
  id: fsk_packet_parser
  parameters:
    address: '[0,0,1,1,1,1,1,0,0,0,1,0,1,0,1,0,0,1,0,1,0,1,0,0,1,0,1,1,0,1,1,1]'
    crc_len: crc_len
    enable_log: Print_metrics
    hdr_len: hdr_len
    log_payload: Print_payload
    payload_len: payload_len
  states: {}
- name: fsk_preamble_detect_0
  id: fsk_preamble_detect
  parameters:
    drate: data_rate
    enable: '1'
    fdev: fdev
    fsamp: samp_rate
    packet_len: packet_len
    threshold: detect_threshold_entry
  states: {}
- name: fsk_synchronization_0
  id: fsk_synchronization
  parameters:
    Grx: rx_gain
    N_Moose: N_Moose
    drate: data_rate
    enable_log: Print_metrics
    fdev: fdev
    fsamp: samp_rate
    hdr_len: hdr_len
    packet_len: packet_len
  states: {}
- name: limesdr_fpga_flag_detector_0
  id: limesdr_fpga_flag_detector
  parameters:
    burst_len: 8*oversampling*(packet_len+1) + oversampling
    enable: Enable_detection
    threshold: '0.99'
  states: {state: disabled}
- name: limesdr_fpga_source_0
  id: limesdr_fpga_source
  parameters:
    AGC_mode: '0'
    AGC_window: '0'
    K: '0'
    RSSI_mode: '0'
    agc_enable: '0'
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 1.5e6
    analog_bandw_ch1: 1.5e6
    calibr_bandw_ch0: 2.5e6
    calibr_bandw_ch1: 2.5e6
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '180'
    desired_output: '0'
    digital_bandw_ch0: samp_rate
    digital_bandw_ch1: samp_rate
    dspcfg_PASSTHROUGH_LEN: '(packet_len+1)*8*int(samp_rate/data_rate)+int(samp_rate/data_rate) '
    dspcfg_THRESHOLD: K_threshold
    dspcfg_fir_en: Enable_FPGA_FIR
    dspcfg_pass_sum_signal: '0'
    dspcfg_preamble_en: Enable_detection
    dspcfg_red_sum_signal: '0'
    filename: ''
    gain_dB_ch0: rx_gain
    gain_dB_ch1: '1'
    lna: '1'
    lna_path_ch0: '255'
    lna_path_ch1: '2'
    nco_freq_ch0: '0'
    nco_freq_ch1: '0'
    oversample: '0'
    pga: '1'
    rf_freq: carrier_freq
    samp_rate: samp_rate
    serial: ''
    tia: '1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: SDR signal
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: byte
    vlen: payload_len
  states: {}

connections:
- [dc_blocker_xx_0, '0', fsk_onQuery_noise_estimation_0, '0']
- [dc_blocker_xx_0, '0', fsk_preamble_detect_0, '0']
- [dc_blocker_xx_0, '0', limesdr_fpga_flag_detector_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [fsk_demodulation_0, '0', fsk_packet_parser_0, '0']
- [fsk_onQuery_noise_estimation_0, NoisePow, fsk_synchronization_0, NoisePow]
- [fsk_packet_parser_0, '0', zeromq_pub_sink_0, '0']
- [fsk_preamble_detect_0, '0', fsk_synchronization_0, '0']
- [fsk_preamble_detect_0, SignalPow, fsk_synchronization_0, SignalPow]
- [fsk_synchronization_0, '0', fsk_demodulation_0, '0']
- [limesdr_fpga_flag_detector_0, '0', fsk_synchronization_0, '0']
- [limesdr_fpga_flag_detector_0, SignalPow, fsk_synchronization_0, SignalPow]
- [limesdr_fpga_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
